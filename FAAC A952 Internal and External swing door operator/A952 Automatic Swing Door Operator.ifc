Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-12-11T12:39:41
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDiscreteAccessory: NBS_FAACEntranceSolutionsUK_CtrldDrClsrs_A952AutomaticSwingDoorOperator:ArticulatedArmLH, NBS_FAACEntranceSolutionsUK_CtrldDrClsrs_A952AutomaticSwingDoorOperator:ArticulatedArmLH:311874
In: Level 0
Type - Material: NBS_FAAC_Aluminium (7)
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_36_59_15:Controlled door closers; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Compact automation for internal and external swing doors.; DurationUnit: year; ExpectedLife: Ten year; Features: n/a; Finish: Anodized,Powder-coated; Grade: n/a; Manufacturer: architect.esuk@faactechnologies.com; Material: Aluminium; ModelNumber: n/a; ModelReference: A952 Automatic Swing Door Operator; Name: ControlledDoorClosers_A952AutomaticSwingDoorOperator_ArticulatedArmLH_FAACEntranceSolutionsUK; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: One year; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_FAACEntranceSolutionsUK_ControlledDoorClosers_A952AutomaticSwingDoorOperator_ArticulatedArmLH; ManufacturerName: FAAC Entrance Solutions UK; ManufacturerURL: https://www.faacentrancesolutions.co.uk/; ProductInformation: https://source.thenbs.com/product/-/c2567877-28e4-46f4-93c6-a2e6a0d9674f/7cd1c530-f9f5-4112-9519-556a267b297f; Uniclass2015Title: Controlled door closers; Uniclass2015Code: Pr_30_36_59_15; Uniclass2015Version: Products v1.36; Version: 1
Type - NBS_Data - Arm: Articulated arm; ClassificationGradesMinimumSuitabilityForUseOnFireAndSmokeDoors: 1; CountryOfMaterialOrigin: Italy; CountryOfProductManufacture: Italy; Dimensions: 715 x 150 x 73 mm; EmbodiedCarbon: 66.0; Form: Overhead, face-fixed; Handing: Left hand; ManufacturingPlantLocation: Via Calari, 10, 40069 Zola Predosa BO, Italy; MaterialsAndFinishesArms: Extruded aluminium; MaterialsAndFinishesBodies: Extruded aluminium; MaterialsAndFinishesCasings: Anodized extruded aluminium; MaterialsAndFinishesColour: Silver anodized,Powder-coated, RAL colour; Mounting: Frame transom mounted,Door mounted,Wall lintel mounted; PowerSupply: 110–240 V; Standard: To EN 16005 and EN 13849; Swing: Inward swing,Outward swing
Type - IFC - IfcExportAs: IfcDiscreteAccessoryType; IfcExportType: USERDEFINED
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
